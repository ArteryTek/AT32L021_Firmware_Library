# Keil uVision project project_l0.uvprojx, settings and files
target project_l0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32L021C8T7 ArteryTek
  pack: ArteryTek.AT32L021_DFP.2.0.3
  cpu: IRAM(0x20000000,0x2400) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project_l0 +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32L021C8T7,USE_STDPERIPH_DRIVER,AT_START_L021_V1
  c include: ..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm0plus\core_support;..\..\..\..\libraries\cmsis\cm0plus\device_support;..\inc;..\..\..\..\project\at32l021_board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2400
  scatter file: .\slib-w-xo.sct
  link misc: --symdefs=fir_filter_symbol.txt
  group user
    ../src/: at32l021_clock.c at32l021_int.c arm_fir_data.c math_helper.c main.c
  group bsp
    ../../../../project/at32l021_board/: at32l021_board.c
  group firmware
    ../../../../libraries/drivers/src/: at32l021_crm.c at32l021_usart.c at32l021_flash.c at32l021_gpio.c at32l021_misc.c
  group cmsis
    ../../../../libraries/cmsis/cm0plus/device_support/: system_at32l021.c
    ../../../../libraries/cmsis/cm0plus/device_support/startup/mdk/: startup_at32l021.s
  group fir_filter
    ../src/: arm_fir_f32.c arm_fir_init_f32.c fir_coefficient.c fir_filter.c
  group readme
    ../: readme.txt
