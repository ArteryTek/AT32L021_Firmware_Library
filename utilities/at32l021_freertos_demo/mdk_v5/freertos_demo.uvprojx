# Keil uVision project freertos_demo.uvprojx, settings and files
target freertos_demo_ac5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32L021C8T7 ArteryTek
  pack: ArteryTek.AT32L021_DFP.2.0.3
  cpu: IRAM(0x20000000,0x2400) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: freertos_demo_ac5 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32L021C8T7,USE_STDPERIPH_DRIVER,AT_START_L021_V1
  c include: ..\inc;..\..\..\libraries\drivers\inc;..\..\..\project\at32l021_board;..\..\..\libraries\cmsis\cm0plus\device_support;..\..\..\libraries\cmsis\cm0plus\core_support;..\..\..\middlewares\freertos\source\include;..\..\..\middlewares\freertos\source\portable\memmang;..\..\..\middlewares\freertos\source\portable\rvds\ARM_CM0
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2400
  group user
    ../src/: at32l021_clock.c at32l021_int.c main.c include_port.c
  group bsp
    ../../../project/at32l021_board/: at32l021_board.c
  group firmware
    ../../../libraries/drivers/src/: at32l021_adc.c at32l021_can.c at32l021_crc.c at32l021_crm.c at32l021_debug.c at32l021_dma.c at32l021_ertc.c at32l021_exint.c at32l021_flash.c at32l021_gpio.c at32l021_hwdiv.c at32l021_i2c.c at32l021_misc.c at32l021_pwc.c at32l021_scfg.c at32l021_spi.c at32l021_tmr.c at32l021_usart.c at32l021_wdt.c at32l021_wwdt.c
  group cmsis
    ../../../libraries/cmsis/cm0plus/device_support/: system_at32l021.c
    ../../../libraries/cmsis/cm0plus/device_support/startup/mdk/: startup_at32l021.s
  group freertos
    ../../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../middlewares/freertos/source/portable/memmang/: heap_4.c
  group readme
    ../: readme.txt
target freertos_demo_ac6 (6160000::V6.16::ARMCLANG)
  device: AT32L021C8T7 ArteryTek
  pack: ArteryTek.AT32L021_DFP.2.0.0
  output: freertos_demo_ac6 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32L021C8T7,USE_STDPERIPH_DRIVER,AT_START_L021_V1
  c include: ..\inc;..\..\..\libraries\drivers\inc;..\..\..\project\at32l021_board;..\..\..\libraries\cmsis\cm0plus\device_support;..\..\..\libraries\cmsis\cm0plus\core_support;..\..\..\middlewares\freertos\source\include;..\..\..\middlewares\freertos\source\portable\memmang;..\..\..\middlewares\freertos\source\portable\GCC\ARM_CM0
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2400
