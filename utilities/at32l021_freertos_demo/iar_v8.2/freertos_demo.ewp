# IAR project freertos_demo.ewp, settings and files
configuration freertos_demo (ARM)
  General.OGChipSelectEditMenu: AT32L021C8T7_v2 ArteryTek - AT32L021C8T7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: AT_START_L021_V1; AT32L021C8T7
  ICCARM.CCIncludePath2: ..\..\..\libraries\drivers\inc; ..\..\..\libraries\cmsis\cm0plus\core_support; ..\..\..\libraries\cmsis\cm0plus\device_support; ..\..\..\middlewares\freertos\source\include; ..\..\..\middlewares\freertos\source\portable\IAR\ARM_CM0; ..\inc; ..\..\..\project\at32l021_board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\middlewares\freertos\source\portable\IAR\ARM_CM4F; ..\inc
  OBJCOPY.OOCOutputFile: freertos_demo.hex
  ILINK.IlinkOutputFile: freertos_demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../project/at32l021_board/: at32l021_board.c
  group cmsis
    ../../../libraries/cmsis/cm0plus/device_support/startup/iar/: startup_at32l021.s
    ../../../libraries/cmsis/cm0plus/device_support/: system_at32l021.c
  group firmware
    ../../../libraries/drivers/src/: at32l021_adc.c at32l021_can.c at32l021_crc.c at32l021_crm.c at32l021_debug.c at32l021_dma.c at32l021_ertc.c at32l021_exint.c at32l021_flash.c at32l021_gpio.c at32l021_hwdiv.c at32l021_i2c.c at32l021_misc.c at32l021_pwc.c at32l021_scfg.c at32l021_spi.c at32l021_tmr.c at32l021_usart.c at32l021_wdt.c at32l021_wwdt.c
  group freertos
    ../../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../middlewares/freertos/source/portable/memmang/: heap_4.c
    ../../../middlewares/freertos/source/portable/IAR/ARM_CM0/: port.c portasm.s
  group readme
    ../: readme.txt
  group user
    ../src/: at32l021_clock.c at32l021_int.c main.c
