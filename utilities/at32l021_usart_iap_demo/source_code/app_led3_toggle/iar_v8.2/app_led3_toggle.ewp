# IAR project app_led3_toggle.ewp, settings and files
configuration app_led3_toggle (ARM, debug)
  General.OGChipSelectEditMenu: AT32L021C8T7_v2 ArteryTek AT32L021C8T7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32L021C8T7; USE_STDPERIPH_DRIVER; AT_START_L021_V1
  ICCARM.CCIncludePath2: ..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\libraries\cmsis\cm0plus\core_support; ..\..\..\..\..\libraries\cmsis\cm0plus\device_support; ..\inc; ..\..\..\..\..\project\at32l021_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: app_led3_toggle.bin
  ILINK.IlinkOutputFile: app_led3_toggle.out
  ILINK.IlinkIcfFile: AT32L021x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../../project/at32l021_board/: at32l021_board.c
  group cmsis
    ../../../../../libraries/cmsis/cm0plus/device_support/startup/iar/: startup_at32l021.s
    ../../../../../libraries/cmsis/cm0plus/device_support/: system_at32l021.c
  group firmware
    ../../../../../libraries/drivers/src/: at32l021_crm.c at32l021_flash.c at32l021_gpio.c at32l021_misc.c at32l021_tmr.c at32l021_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32l021_clock.c at32l021_int.c iap.c main.c tmr.c usart.c
