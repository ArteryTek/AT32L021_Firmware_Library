# IAR project printf.ewp, settings and files
configuration printf (ARM)
  General.OGChipSelectEditMenu: AT32L021C8T7_v2 ArteryTek AT32L021C8T7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32L021C8T7; USE_STDPERIPH_DRIVER; AT_START_L021_V1
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\..\libraries\cmsis\cm0plus\core_support; ..\..\..\..\..\..\libraries\cmsis\cm0plus\device_support; ..\inc; ..\..\..\..\..\at32l021_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: printf.srec
  ILINK.IlinkOutputFile: printf.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../../at32l021_board/: at32l021_board.c
  group cmsis
    ../../../../../../libraries/cmsis/cm0plus/device_support/startup/iar/: startup_at32l021.s
    ../../../../../../libraries/cmsis/cm0plus/device_support/: system_at32l021.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32l021_crm.c at32l021_gpio.c at32l021_misc.c at32l021_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32l021_int.c at32l021_clock.c main.c
