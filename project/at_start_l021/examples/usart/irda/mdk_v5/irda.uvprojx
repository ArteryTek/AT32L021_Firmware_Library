# Keil uVision project irda.uvprojx, settings and files
target transmit (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32L021C8T7 ArteryTek
  pack: ArteryTek.AT32L021_DFP.2.0.3
  cpu: IRAM(0x20000000,0x2400) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: transmit +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32L021C8T7,USE_STDPERIPH_DRIVER,AT_START_L021_V1,TRANSMIT
  c include: ..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm0plus\core_support;..\..\..\..\..\..\libraries\cmsis\cm0plus\device_support;..\inc;..\..\..\..\..\at32l021_board
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2400
  group user
    ../src/: at32l021_clock.c at32l021_int.c main.c
  group bsp
    ../../../../../at32l021_board/: at32l021_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32l021_gpio.c at32l021_crm.c at32l021_usart.c at32l021_misc.c
  group cmsis
    ../../../../../../libraries/cmsis/cm0plus/device_support/: system_at32l021.c
    ../../../../../../libraries/cmsis/cm0plus/device_support/startup/mdk/: startup_at32l021.s
  group readme
    ../: readme.txt
target receive (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32L021C8T7 ArteryTek
  pack: ArteryTek.AT32L021_DFP.2.0.0
  cpu: as above
  output: receive +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32L021C8T7,USE_STDPERIPH_DRIVER,AT_START_L021_V1,RECEIVE
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2400
