# Keil uVision project template.uvproj, settings and files
target tempate (ARM-ADS)
  device: AT32L021C8T7 ArteryTek
  output: Template +hex
  c flags: Optim=1
  c define: AT32L021C8T7,USE_STDPERIPH_DRIVER,AT_START_L021_V1
  c include: ..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm0plus\core_support;..\..\..\..\libraries\cmsis\cm0plus\device_support;..\inc;..\..\..\at32l021_board
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2400
  group user
    ../src/: at32l021_int.c at32l021_clock.c main.c
  group bsp
    ../../../at32l021_board/: at32l021_board.c
  group cmsis
    ../../../../libraries/cmsis/cm0plus/device_support/startup/mdk/: startup_at32l021.s
    ../../../../libraries/cmsis/cm0plus/device_support/: system_at32l021.c
  group firmware
    ../../../../libraries/drivers/src/: at32l021_adc.c at32l021_can.c at32l021_crc.c at32l021_crm.c at32l021_debug.c at32l021_dma.c at32l021_ertc.c at32l021_exint.c at32l021_flash.c at32l021_gpio.c at32l021_hwdiv.c at32l021_i2c.c at32l021_misc.c at32l021_pwc.c at32l021_scfg.c at32l021_spi.c at32l021_tmr.c at32l021_usart.c at32l021_wdt.c at32l021_wwdt.c
  group readme
    ../: readme.txt
