# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32L021C8T7_v2 ArteryTek AT32L021C8T7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: AT32L021C8T7; USE_STDPERIPH_DRIVER; AT_START_L021_V1
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm0plus\core_support; ..\..\..\..\libraries\cmsis\cm0plus\device_support; ..\inc; ..\..\..\at32l021_board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.hex
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group bsp
    ../../../at32l021_board/: at32l021_board.c
  group cmsis
    ../../../../libraries/cmsis/cm0plus/device_support/startup/iar/: startup_at32l021.s
    ../../../../libraries/cmsis/cm0plus/device_support/: system_at32l021.c
  group firmware
    ../../../../libraries/drivers/src/: at32l021_adc.c at32l021_can.c at32l021_crc.c at32l021_crm.c at32l021_debug.c at32l021_dma.c at32l021_ertc.c at32l021_exint.c at32l021_flash.c at32l021_gpio.c at32l021_hwdiv.c at32l021_i2c.c at32l021_misc.c at32l021_pwc.c at32l021_scfg.c at32l021_spi.c at32l021_tmr.c at32l021_usart.c at32l021_wdt.c at32l021_wwdt.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32l021_clock.c at32l021_int.c main.c
